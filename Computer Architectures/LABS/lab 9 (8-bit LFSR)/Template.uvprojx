# Keil uVision project Template.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Main
    ./: Main.c Main.h
  group Timer
    ./Timer/: IRQ_timer.c lib_timer.c timer.h
  group Button
    ./Button/: button.h IRQ_button.c lib_button.c
  group LED
    ./LED/: funct_led.c led.h lib_led.c
  group Joystick
    ./joystick/: joystick.h lib_joystick.c
  group RIT
    ./RIT/: IRQ_RIT.c lib_RIT.c RIT.h
  group ADC
    ./ADC/: adc.h IRQ_adc.c lib_adc.c
  group GLCD
    ./GLCD/: AsciiLib.c AsciiLib.h GLCD.c GLCD.h HzLib.c HzLib.h
  group TouchPanel
    ./TouchPanel/: TouchPanel.c TouchPanel.h
  group Assembly
    ./Assembly/: 1BYTE SORTING.s
    ./: next_state.s
  group DAC
    ./DAC/: DAC.c DAC.h
  group Materials
    ./Materials/: Materials.txt
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
